# Keil uVision project iRTOS.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: iRTOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./Source/: main.c switch.c list.c app.c bitmap.c cpu.c scheduler.c time.c event.c sem.c config.h event.h lib.h scheduler.h sem.h task.h msgbox.c msgbox.h memblock.c memblock.h flaggroup.c flaggroup.h mutex.c mutex.h timer.h timer.c hooks.c hooks.h irtos.h task.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
